# Keil uVision project Proj1.uvproj, settings and files
target Blinking (ARM-ADS)
  device: STM32F407VG STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: Proj1
  c flags: Optim=1
  c define: HSE_VALUE=8000000,USE_STDPERIPH_DRIVER
  c include: .\STDLIB;C:\ARM\STM32F4xx_DSP_StdPeriph_Lib_V1.3.0\Libraries\STM32F4xx_StdPeriph_Driver\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Source Group 1
    ./: startup_stm32f40_41xxx.s
  group CMSIS
    ./CMSIS/: system_stm32f4xx.c
  group USER
    ./USER/: main.c
  group StdLib
    ./STDLIB/: stm32f4xx_conf.h misc.c stm32f4xx_gpio.c stm32f4xx_rcc.c
